# Keil uVision project mudmax_tx.uvproj, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ADuC7060 Analog Devices
  cpu: IRAM(0x40000-0x40FFF) IROM(0x80000-0x877FF) CLOCK(32768) CPUTYPE(ARM7TDMI)
  output: mudmax_tx +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x80000 size 0x7800
  memory RVCT9: RAM 0x40000 size 0x1000
  group Source Group 1
    ./: ADuC706x.s main.c config.c config.h interrupt_handlers.c interrupt_handlers.h aduc7060_helpers.c irq_arm.c aduc7060_helpers.h adc.h adc.c
